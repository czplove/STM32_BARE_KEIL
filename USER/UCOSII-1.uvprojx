# Keil uVision project UCOSII-1.uvprojx, settings and files
target UCOSII-1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOSII-1 +hex
  AfterMake: fromelf --bin --output ..\OBJ\UCOSII-1.bin ..\OBJ\UCOSII-1.axf
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\inc;..\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_flash.c
  group UCOSII-CORE
    ../UCOSII/CORE/: RTOS.c RTOS_ASM.s
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
  group src
    ../src/: tiza_driver.c tiza_selfdef.c
  group inc
    ../inc/: tiza_include.h tiza_business.h tiza_driver.h tiza_flash.h tiza_ftp.h tiza_l218.h tiza_protocol.h tiza_spi_flash.h tiza_systask.h tiza_can.h tiza_syspara.h
